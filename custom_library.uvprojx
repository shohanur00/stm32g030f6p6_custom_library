# Keil uVision project custom_library.uvprojx, settings and files
target stm32g030f6p6 (6210000::V6.21::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: custom_library
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./: main.c flash.c gpio.c app.c crc32.c timebase.c sw_timebase.c
  group inc
    ./: flash.h gpio.h app.h crc32.h timebase.h sw_timebase.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.4.2
